void kurve_verlauf()
{
  
  analogWrite(backlight_pin, backlight_on);
    
  int x, y;
  int res = 0;
     
 waitForTouchRelease();    
  
  myGLCD.clrScr();

  //Skalen Zeichnen
  
   myGLCD.drawLine(45, 230, 65, 230); //1
   
   
   
  
   //Graphen zeichen
  
  drawKurveTempInnen();
  //drawKurveHumInnen;
  
 // drawKurveTempAussen;
 // drawKurveHumAussen);
     
   
  // Zurück zum Hauptbildschirm
    
  while (res==0)
  {
    if (myTouch.dataAvailable())
    {
      myTouch.read();
      x=myTouch.getX();
      y=myTouch.getY();
      
       if ((y>=0) && (y<=480)) // Touchbereich um zurückzukehren
      {
        if ((x>=0) && (x<=800))
        {
          res=2;
          myGLCD.setColor (255, 0, 0);
          myGLCD.drawRoundRect(1, 1, 799, 479);
        }
      }
    }
  }
  
  waitForTouchRelease();
  
myGLCD.clrScr();

  initGraphics();
  renderDatum();
  renderTempInnen();
  renderTempAussen();
  renderBarometer();
  rendertaupunkt();
  renderhumidex();
  renderaktuell();
  renderforecast();
  rendermoon();
  rendermoondays();
  rendersonne();
  renderheizung(); 
  drawMillibarGraph(historyBaro, 24);
 
}

//******************* KURVEN ************************

//Temp Innen

void drawKurveTempInnen(){
  
myGLCD.setColor(0,255,0);
//------------------------------------------------------------------------------------------------------------ -Draw Line at 0.00 Uhr
myGLCD.drawLine(21,t1p0y1,33,t1p1y1);
//------------------------------------------------------------------------------------------------------------ -Draw Line at 1.00 Uhr
myGLCD.drawLine(33,t1p1y1,45,t1p2y1);
//------------------------------------------------------------------------------------------------------------ -Draw Line at 2.00 Uhr
myGLCD.drawLine(45,t1p2y1,57,t1p3y1);
//------------------------------------------------------------------------------------------------------------ -Draw Line at 3.00 Uhr
myGLCD.drawLine(57,t1p3y1,69,t1p4y1);
//------------------------------------------------------------------------------------------------------------ -Draw Line at 4.00 Uhr
myGLCD.drawLine(69,t1p4y1,81,t1p5y1);
//------------------------------------------------------------------------------------------------------------ -Draw Line at 5.00 Uhr
myGLCD.drawLine(81,t1p5y1,93,t1p6y1);
//------------------------------------------------------------------------------------------------------------ -Draw Line at 6.00 Uhr
myGLCD.drawLine(93,t1p6y1,105,t1p7y1);
//------------------------------------------------------------------------------------------------------------ -Draw Line at 7.00 Uhr
myGLCD.drawLine(105,t1p7y1,117,t1p8y1);
//------------------------------------------------------------------------------------------------------------ -Draw Line at 8.00 Uhr
myGLCD.drawLine(117,t1p8y1,129,t1p9y1);
//------------------------------------------------------------------------------------------------------------ -Draw Line at 9.00 Uhr
myGLCD.drawLine(129,t1p9y1,141,t1p10y1);
//----------------------------------------------------------------------------------------------------------- -Draw Line at 10.00 Uhr
myGLCD.drawLine(141,t1p10y1,153,t1p11y1);
//----------------------------------------------------------------------------------------------------------- -Draw Line at 11.00 Uhr
myGLCD.drawLine(153,t1p11y1,165,t1p12y1);
//----------------------------------------------------------------------------------------------------------- -Draw Line at 12.00 Uhr
myGLCD.drawLine(165,t1p12y1,177,t1p13y1);
//----------------------------------------------------------------------------------------------------------- -Draw Line at 13.00 Uhr
myGLCD.drawLine(177,t1p13y1,189,t1p14y1);
//----------------------------------------------------------------------------------------------------------- -Draw Line at 14.00 Uhr
myGLCD.drawLine(189,t1p14y1,201,t1p15y1);
//----------------------------------------------------------------------------------------------------------- -Draw Line at 15.00 Uhr
myGLCD.drawLine(201,t1p15y1,213,t1p16y1);
//----------------------------------------------------------------------------------------------------------- -Draw Line at 16.00 Uhr
myGLCD.drawLine(213,t1p16y1,225,t1p17y1);
//----------------------------------------------------------------------------------------------------------- -Draw Line at 17.00 Uhr
myGLCD.drawLine(225,t1p17y1,237,t1p18y1);
//----------------------------------------------------------------------------------------------------------- -Draw Line at 18.00 Uhr
myGLCD.drawLine(237,t1p18y1,249,t1p19y1);
//----------------------------------------------------------------------------------------------------------- -Draw Line at 19.00 Uhr
myGLCD.drawLine(249,t1p19y1,261,t1p20y1);
//----------------------------------------------------------------------------------------------------------- -Draw Line at 20.00 Uhr
myGLCD.drawLine(261,t1p20y1,273,t1p21y1);
//----------------------------------------------------------------------------------------------------------- -Draw Line at 21.00 Uhr
myGLCD.drawLine(273,t1p21y1,285,t1p22y1);
//----------------------------------------------------------------------------------------------------------- -Draw Line at 22.00 Uhr
myGLCD.drawLine(285,t1p22y1,297,t1p23y1);
//----------------------------------------------------------------------------------------------------------- -Draw Line at 23.00 Uhr
myGLCD.drawLine(297,t1p23y1,309,t1p0y1);
}
//------------------------------------}

//Temp Aussen


//Hum Innen



//Hum Aussen


